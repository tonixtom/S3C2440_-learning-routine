# Keil uVision project 2440.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: 2440_for_test
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\inc
  memory RVCT1: ROM 0x30000000 size 0x800000
  memory RVCT6: RAM 0x30800000 size 0x800000
  memory RVCT9: RAM 0x40000000 size 0x1000
  link misc: --sort=CallTree
  group Main
    ./src/: 2440init.s 2440lib.c 2440slib.s Adc.c AudioDrv.c camif.c camproset.c dma.c eeprom.c IIC.c IrDA.c keyscan.c LCD_TFT.c Main.c memtest.c mmu.c nand.c Pic.c profile.c RTC.c SD_MMC.c Test_OV9650.c Touchpanel.c TQ_LOGO.c UDA1341.c 2440addr.inc Memcfg.inc Option.inc
